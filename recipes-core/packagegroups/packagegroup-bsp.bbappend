# Various packages needed for all boards
RDEPENDS_packagegroup-bsp-custom_append = " \
    e2fsprogs-resize2fs \
"
