# Conflicts with eviewitf
RDEPENDS_packagegroup-v3x_remove = " \
    kernel-module-iccom \
    libiccom \
"
