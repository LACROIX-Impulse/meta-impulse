require recipes-core/images/rcar-image.inc

