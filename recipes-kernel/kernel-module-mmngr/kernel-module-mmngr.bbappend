MMNGR_CFG_ecube = "MMNGR_V3MSK"
